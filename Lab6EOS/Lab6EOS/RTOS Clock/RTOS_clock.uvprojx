# Keil uVision project RTOS_clock.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F207IGHx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RTOS_clock
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: main.c displayTime.c rtosClockObjects.h Second.c Minute.c Hour.c
software components: CMSIS:CORE 5.0.1, CMSIS:RTOS2:Keil RTX5 5.1.0, Board Support:Buttons 2.0.0, Board Support:Graphic LCD 2.0.0, Board Support:LED 2.0.0, CMSIS Driver:I2C 2.7, Device:STM32Cube Framework:Classic 1.1.1, Device:STM32Cube HAL:ADC 1.1.1, Device:STM32Cube HAL:Common 1.1.1, Device:STM32Cube HAL:Cortex 1.1.1, Device:STM32Cube HAL:DCMI 1.1.1, Device:STM32Cube HAL:DMA 1.1.1, Device:STM32Cube HAL:GPIO 1.1.1, Device:STM32Cube HAL:I2C 1.1.1, Device:STM32Cube HAL:RCC 1.1.1, Device:STM32Cube HAL:SRAM 1.1.1, Device:STM32Cube HAL:USART 1.1.1, Device:Startup 2.1.1
